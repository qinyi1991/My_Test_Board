# IAR project IarDemo-F4XG.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; STM32F407xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\BSP; ..\..\BSP\OS\uCOS-III; ..\..\BSP\CMSIS; ..\..\..\Drivers\CMSIS\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\Software\uC-CPU; ..\..\..\..\Software\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\Software\uC-LIB; ..\..\..\..\Software\uC-LIB\Ports\ARM-Cortex-M4\IAR; ..\..\..\..\Software\uCOS-III\Source; ..\..\..\..\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\Software\uC-Serial\Driver\ST; ..\..\..\..\Software\uC-Serial\Line; ..\..\..\..\Software\uC-Serial\OS\uCOS-III; ..\..\..\..\Software\uC-Serial\Source; ..\..\..\..\Software\uC-Serial\OS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IarDemo-F4XG.srec
  ILINK.IlinkOutputFile: IarDemo-F4XG.out
  ILINK.IlinkIcfFile: F:\2016---工作项目资料\Mars项目组\Mars项目资料\IarDemo-F4XG\IarDemo-F4XG\IarDemoF4XG-User\BSP\IAR\STM32F4xx_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: IarDemo-F4XG.hex
  group App
    ../: app.c os_app_hooks.c
  group App/APP-CFG
    ../: app_cfg.h app_serial.h os_app_hooks.h stm32f4xx_hal_conf.h
  group BSP/Headers
    ../../BSP/: bsp.h serial_bsp_stm3240x.h sys.h
  group BSP/Source
    ../../BSP/: bsp.c bsp_CANbus.c bsp_DACoutput.c bsp_EncoderScan.c bsp_FSMC_ADC7606.c bsp_I3G4250D.c bsp_IICbusDrive.c bsp_IIS328Q.c bsp_int.c bsp_periph.c bsp_SPIbus.c cpu_bsp.c DataScope_DP.C DataScope_DP.h modbus.c serial_bsp_rs485.c serial_bsp_stm3240x.c
    ../../BSP/IAR/: cstartup.c
    ../../BSP/CMSIS/: system_stm32f4xx.c
  group BSP/Stm32Libraries-Cube/inc
    ../../../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group BSP/Stm32Libraries-Cube/inc/Legacy
    ../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group BSP/Stm32Libraries-Cube/src
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group CFG-Libraries
    ../: cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
    ../../../../Software/uCOS-III/Source/: os_type.h
  group CFG-Libraries/CMSIS/Device/ST/STM32F4xx/Include
    ../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include/: stm32f407xx.h stm32f4xx.h system_stm32f4xx.h
  group CFG-Libraries/CMSIS/Include
    ../../../Drivers/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group uC/CPU
    ../../../../Software/uC-CPU/ARM-Cortex-M4/IAR/: cpu.h cpu_a.asm cpu_c.c
    ../../../../Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III
    ../../../../Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../../Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
